## kernel/Kconfig.kgraft
```kconfig
config HAVE_KGRAFT
	bool

config KGRAFT
	bool "kGraft infrastructure"
	depends on DYNAMIC_FTRACE_WITH_REGS
	depends on HAVE_KGRAFT
```
